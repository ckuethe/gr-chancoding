<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>chancoding_ber_b</key>
<param><key>id</key><value>chancoding_ber_b_1</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Coded</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Uncoded</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>3200</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>chancoding_ber_b</key>
<param><key>id</key><value>chancoding_ber_b_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
</block>
<block>
<key>chancoding_bsc_bb</key>
<param><key>id</key><value>chancoding_bsc_bb_1</value></param>
<param><key>ber</key><value>0.01</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
</block>
<block>
<key>chancoding_rmg_decoder_bb</key>
<param><key>id</key><value>chancoding_rmg_decoder_bb_0</value></param>
<param><key>m</key><value>4</value></param>
<param><key>num_bits_precoded</key><value>3</value></param>
</block>
<block>
<key>chancoding_rmg_encoder_bb</key>
<param><key>id</key><value>chancoding_rmg_encoder_bb_0</value></param>
<param><key>m</key><value>4</value></param>
<param><key>num_bits_precoded</key><value>3</value></param>
</block>
<block>
<key>chancoding_bsc_bb</key>
<param><key>id</key><value>chancoding_bsc_bb_0</value></param>
<param><key>ber</key><value>0.01</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
</block>
<connection><source_block_id>chancoding_rmg_encoder_bb_0</source_block_id><sink_block_id>chancoding_bsc_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chancoding_bsc_bb_1</source_block_id><sink_block_id>chancoding_rmg_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chancoding_rmg_decoder_bb_0</source_block_id><sink_block_id>chancoding_ber_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chancoding_bsc_bb_0</source_block_id><sink_block_id>chancoding_ber_b_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>chancoding_ber_b_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chancoding_ber_b_1</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>chancoding_rmg_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>chancoding_ber_b_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>chancoding_ber_b_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>chancoding_bsc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
